<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>4160</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>demod_rate</value></param>
<param><key>value</key><value>baud_rate * factor_of_baud</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>factor_of_baud</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>11025</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>label</key><value>Signal Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>800</value></param>
</block>
<block>
<key>apt_am_demod</key>
<param><key>id</key><value>apt_am_demod_0</value></param>
<param><key>parameter_apt_gain</key><value>signal_gain</value></param>
<param><key>parameter_samp_rate</key><value>11.025e3</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/Users/bjmclaug/source/stem_station/raw_meta.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_seg_size</key><value>baud_rate * (60 * 20)</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>baud_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>fm_demodulated_source</value></param>
<param><key>file</key><value>/Users/bjmclaug/source/stem_station/sample_files/N18_4827.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>zmax</key><value>0.75</value></param>
<param><key>zmin</key><value>-0.5</value></param>
<param><key>color1</key><value>1</value></param>
<param><key>ncols</key><value>int(baud_rate / 2)</value></param>
<param><key>nrows</key><value>128</value></param>
<param><key>samp_rate</key><value>baud_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>'APT Full Line'</value></param>
<param><key>size</key><value>baud_rate / 2</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_tag</key><value>'SyncA'</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<connection><source_block_id>apt_am_demod_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>apt_am_demod_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>apt_am_demod_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>apt_am_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>apt_am_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_demodulated_source</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
