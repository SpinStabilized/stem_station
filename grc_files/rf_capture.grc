<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>apt_rx</value></param>
<param><key>author</key><value>Brian McLaughlin</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>'NOAA APT Satellite Receiver'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>4160</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>1.024e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>satellite_freq</value></param>
<param><key>value</key><value>137.62e6</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>baseband_notebook</value></param>
<param><key>labels</key><value>['Spectrum', 'Analog Signal']</value></param>
<param><key>notebook</key><value>top_notebook, 1</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/brian/stem_station/raw_baud_x_24.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>if_receive_notebook</value></param>
<param><key>labels</key><value>['FFT', 'Waterfall']</value></param>
<param><key>notebook</key><value>top_notebook, 0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>corr0</key><value>9</value></param>
<param><key>freq0</key><value>satellite_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>49.6</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>baud_rate * 24</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>top_notebook</value></param>
<param><key>labels</key><value>['Satellite Receive', 'Baseband']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>satellite_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>if_receive_notebook, 0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>baud_rate * 24</value></param>
<param><key>title</key><value>Intermediate Frequency Receive Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>5</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>satellite_freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>if_receive_notebook, 1</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>samp_rate</key><value>baud_rate * 24</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.flattop</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
